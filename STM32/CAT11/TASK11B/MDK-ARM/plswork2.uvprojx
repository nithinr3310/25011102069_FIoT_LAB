# Keil uVision project plswork2.uvprojx, settings and files
target plswork2 ()
  c define: USE_HAL_DRIVER;STM32F103xB
  c include: ..\Core\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include
  group Application and HAL
    ../Core/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c syscalls.c sysmem.c system_stm32f1xx.c
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
  group Startup
    ./: startup_stm32f103c8tx.s
